# Keil uVision project calculator.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: calculator +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\CORE;..\LIB;..\LIB\inc;..\LIB\src;..\SYSTEM\sys;..\HARDWARE\LCD;..\SYSTEM\delay;..\HARDWARE\SPI;..\HARDWARE\W25QXX;..\HARDWARE\TOUCH
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group user
    ./: main.c stm32f10x.h stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h system_stm32f10x.c system_stm32f10x.h
  group lib
    ../LIB/inc/: misc.h stm32f10x_rcc.h stm32f10x_fsmc.h stm32f10x_spi.h stm32f10x_gpio.h
    ../LIB/src/: misc.c stm32f10x_spi.c stm32f10x_rcc.c stm32f10x_gpio.c stm32f10x_fsmc.c
    ../CORE/: core_cm3.c core_cm3.h startup_stm32f10x_hd.s
    ../HARDWARE/LCD/: FONT.c FONT.H lcd.c lcd.h
    ../SYSTEM/sys/: sys.c sys.h
    ../SYSTEM/delay/: delay.c delay.h
    ../HARDWARE/W25QXX/: w25qxx.c w25qxx.h
    ../HARDWARE/SPI/: spi.c spi.h
    ../HARDWARE/TOUCH/: touch.c touch.h
